# SPDX-License-Identifier: MIT
# SPDX-FileCopyrightText: 2025 Bartosz Golaszewski <bartosz.golaszewski@linaro.org>

RRECOMMENDS:${PN}:remove = " phonon-backend-vlc"
